# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\FreeRTOS\inc;.\FreeRTOS\port;.\FreeRTOS\src;.\Drivers\BSP;.\Drivers\STM32F10x_StdPeriph_Driver;.\Drivers\CMSIS;.\Middlewares\Algorithm;.\Middlewares\Utils;.\App\Model;.\App\UI;.\App\Tasks;.\App\UI\Pages;.\App\Config
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h freertos_debug.h freertos_debug.c
  group FreeRTOS\inc
    ./FreeRTOS/inc/: atomic.h CMakeLists.txt croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS\port
    ./FreeRTOS/port/: heap_4.c port.c portmacro.h
  group FreeRTOS\src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Drivers/StdPeriph
    ./Drivers/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers/BSP
    ./Drivers/BSP/: bsp_rtc.c bsp_usart.c bsp_timer.c bsp_adc.c bsp_key.c bsp_led.c bsp_mpu6050.c bsp_i2c.c bsp_oled.c bsp_spi.c bsp_flash.c bsp_delay.c bsp_sys.c OLED_Data.c
  group Drivers/CMSIS
    ./Drivers/CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_md.s stm32f10x.h
  group Middlewares/Alogorithm
    ./Middlewares/Algorithm/: kalman.c pedometer.c step_algo.c
  group Middlewares/Utils
    ./Middlewares/Utils/: debug_serial.c
  group App/Tasks
    ./App/Tasks/: task_datasync.c task_display.c task_input.c task_manager.c task_sensor.c
  group App/Config
    ./App/Config/: app_config.h FreeRTOSConfig.h
  group App/Model
    ./App/Model/: DataCenter.c SetTime.c Storage.c
  group App/UI
    ./App/UI/: UI_Manager.c dino.c menu.c
  group UI\Pages
    ./App/UI/Pages/: Page_Apps.c Page_Clock.c Page_Menu.c
